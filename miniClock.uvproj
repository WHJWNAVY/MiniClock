# Keil uVision project miniClock.uvproj, settings and files
target miniClock (MCS-51)
  device: STC8F2K64S4 STC
  cpu: IRAM(0-0xFF) XRAM(0-0x07FF) IROM(0-0xFFF8) CLOCK(35000000) MODP2
  output: miniClock +hex
  BeforeMake: .\version.exe
  AfterMake: .\backup.exe
  c flags: Optimize=8 SizeSpeed=1
  link misc: REMOVEUNUSED
  group main
    ./src/: china_nonli.c common.c drv_18b20.c drv_1302.c drv_3231.c drv_cfg.c drv_key.c drv_led.c gpio_i2c.c main.c
